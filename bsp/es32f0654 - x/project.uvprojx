# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES32F0654LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .;..\..\include;applications;.;drivers;libraries\CMSIS\Device\EastSoft\ES32F065x\Include;libraries\CMSIS\Include;libraries\ES32F065x_ALD_StdPeriph_Driver\Include;packages\dht11-latest;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\sensors;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\common;..\..\components\utilities\ulog
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: Blue.c LED.c main.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Libraries
    libraries/ES32F065x_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dma.c ald_flash.c ald_gpio.c ald_i2c.c ald_iap.c ald_pis.c ald_pmu.c ald_rmu.c ald_rtc.c ald_smartcard.c ald_spi.c ald_temp.c ald_timer.c ald_trng.c ald_uart.c ald_usart.c ald_wdt.c utils.c
    libraries/CMSIS/Device/EastSoft/ES32F065x/Startup/keil/: startup_es32f065x.s
  group dht11
    packages/dht11-latest/: sensor_dallas_dht11.c dht11_sample.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    ../../components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
